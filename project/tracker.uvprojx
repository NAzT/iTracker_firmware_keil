# Keil uVision project tracker.uvprojx, settings and files
target tracker (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: iTracker +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_NFCT_PINS_AS_GPIOS CONFIG_GPIO_AS_PINRESET
  c misc: --reduce_paths
  c include: ..\..\..\config;..\nRF5_SDK\components;..\nRF5_SDK\components\ble\ble_advertising;..\nRF5_SDK\components\ble\ble_dtm;..\nRF5_SDK\components\ble\ble_racp;..\nRF5_SDK\components\ble\ble_services\ble_ancs_c;..\nRF5_SDK\components\ble\ble_services\ble_ans_c;..\nRF5_SDK\components\ble\ble_services\ble_bas;..\nRF5_SDK\components\ble\ble_services\ble_bas_c;..\nRF5_SDK\components\ble\ble_services\ble_cscs;..\nRF5_SDK\components\ble\ble_services\ble_cts_c;..\nRF5_SDK\components\ble\ble_services\ble_dfu;..\nRF5_SDK\components\ble\ble_services\ble_dis;..\nRF5_SDK\components\ble\ble_services\ble_gls;..\nRF5_SDK\components\ble\ble_services\ble_hids;..\nRF5_SDK\components\ble\ble_services\ble_hrs;..\nRF5_SDK\components\ble\ble_services\ble_hrs_c;..\nRF5_SDK\components\ble\ble_services\ble_hts;..\nRF5_SDK\components\ble\ble_services\ble_ias;..\nRF5_SDK\components\ble\ble_services\ble_ias_c;..\nRF5_SDK\components\ble\ble_services\ble_lbs;..\nRF5_SDK\components\ble\ble_services\ble_lbs_c;..\nRF5_SDK\components\ble\ble_services\ble_lls;..\nRF5_SDK\components\ble\ble_services\ble_nus;..\nRF5_SDK\components\ble\ble_services\ble_nus_c;..\nRF5_SDK\components\ble\ble_services\ble_rscs;..\nRF5_SDK\components\ble\ble_services\ble_rscs_c;..\nRF5_SDK\components\ble\ble_services\ble_tps;..\nRF5_SDK\components\ble\common;..\nRF5_SDK\components\ble\nrf_ble_gatt;..\nRF5_SDK\components\ble\nrf_ble_qwr;..\nRF5_SDK\components\ble\peer_manager;..\nRF5_SDK\components\boards;..\nRF5_SDK\components\drivers_nrf\clock;..\nRF5_SDK\components\drivers_nrf\common;..\nRF5_SDK\components\drivers_nrf\comp;..\nRF5_SDK\components\drivers_nrf\delay;..\nRF5_SDK\components\drivers_nrf\gpiote;..\nRF5_SDK\components\drivers_nrf\hal;..\nRF5_SDK\components\drivers_nrf\i2s;..\nRF5_SDK\components\drivers_nrf\lpcomp;..\nRF5_SDK\components\drivers_nrf\pdm;..\nRF5_SDK\components\drivers_nrf\power;..\nRF5_SDK\components\drivers_nrf\ppi;..\nRF5_SDK\components\drivers_nrf\pwm;..\nRF5_SDK\components\drivers_nrf\qdec;..\nRF5_SDK\components\drivers_nrf\rng;..\nRF5_SDK\components\drivers_nrf\rtc;..\nRF5_SDK\components\drivers_nrf\saadc;..\nRF5_SDK\components\drivers_nrf\spi_master;..\nRF5_SDK\components\drivers_nrf\spi_slave;..\nRF5_SDK\components\drivers_nrf\swi;..\nRF5_SDK\components\drivers_nrf\timer;..\nRF5_SDK\components\drivers_nrf\twi_master;..\nRF5_SDK\components\drivers_nrf\twis_slave;..\nRF5_SDK\components\drivers_nrf\uart;..\nRF5_SDK\components\drivers_nrf\usbd;..\nRF5_SDK\components\drivers_nrf\wdt;..\nRF5_SDK\components\libraries\atomic;..\nRF5_SDK\components\libraries\atomic_fifo;..\nRF5_SDK\components\libraries\balloc;..\nRF5_SDK\components\libraries\bsp;..\nRF5_SDK\components\libraries\button;..\nRF5_SDK\components\libraries\crc16;..\nRF5_SDK\components\libraries\crc32;..\nRF5_SDK\components\libraries\csense;..\nRF5_SDK\components\libraries\csense_drv;..\nRF5_SDK\components\libraries\ecc;..\nRF5_SDK\components\libraries\experimental_cli;..\nRF5_SDK\components\libraries\experimental_log;..\nRF5_SDK\components\libraries\experimental_log\src;..\nRF5_SDK\components\libraries\experimental_memobj;..\nRF5_SDK\components\libraries\experimental_section_vars;..\nRF5_SDK\components\libraries\fds;..\nRF5_SDK\components\libraries\fifo;..\nRF5_SDK\components\libraries\fstorage;..\nRF5_SDK\components\libraries\gpiote;..\nRF5_SDK\components\libraries\hardfault;..\nRF5_SDK\components\libraries\hci;..\nRF5_SDK\components\libraries\led_softblink;..\nRF5_SDK\components\libraries\low_power_pwm;..\nRF5_SDK\components\libraries\mem_manager;..\nRF5_SDK\components\libraries\mutex;..\nRF5_SDK\components\libraries\pwm;..\nRF5_SDK\components\libraries\pwr_mgmt;..\nRF5_SDK\components\libraries\queue;..\nRF5_SDK\components\libraries\scheduler;..\nRF5_SDK\components\libraries\slip;..\nRF5_SDK\components\libraries\strerror;..\nRF5_SDK\components\libraries\timer;..\nRF5_SDK\components\libraries\twi;..\nRF5_SDK\components\libraries\uart;..\nRF5_SDK\components\libraries\usbd;..\nRF5_SDK\components\libraries\usbd\class\audio;..\nRF5_SDK\components\libraries\usbd\class\cdc;..\nRF5_SDK\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK\components\libraries\usbd\class\hid;..\nRF5_SDK\components\libraries\usbd\class\hid\generic;..\nRF5_SDK\components\libraries\usbd\class\hid\kbd;..\nRF5_SDK\components\libraries\usbd\class\hid\mouse;..\nRF5_SDK\components\libraries\usbd\class\msc;..\nRF5_SDK\components\libraries\usbd\config;..\nRF5_SDK\components\libraries\util;..\nRF5_SDK\components\softdevice\common;..\nRF5_SDK\components\softdevice\s132\headers;..\nRF5_SDK\components\softdevice\s132\headers\nrf52;..\nRF5_SDK\components\toolchain;..\nRF5_SDK\external\fprintf;..\nRF5_SDK\external\segger_rtt;..\source\lora\src\mac;..\source\lora\src\mac\region;..\source\lora\src\peripherals;..\source\lora\src\radio;..\source\lora\src\system;..\source\lora\src\system\crypto;..\source\lora\src\boards\RAK813;..\source\lora\src\apps\classA;..\source\lora\src\peripherals;..\source\usr\inc
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_cli;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002760 size 0xd8a0
  link misc: --diag_suppress 6330
  group app\
    ../source/usr/src/: main.c bsp_itracker.c
    ../source/usr/inc/: sdk_config.h
  group app\peripherals
    ../source/usr/src/: bme280.c lis3dh_driver.c sensor_opt3001.c lis2mdl_reg.c gps.c rak_uart_dev.c rak_uart_gsm.c rak_uart_gps.c rak_spi_sensor.c rak_spi_bme280.c rak_i2c_sensor.c rak_i2c_opt3001.c rak_i2c_lis3dh.c rak_i2c_lis2mdl.c board.c gpio-board.c gps-board.c utilities.c
  group Board Definition
    ../nRF5_SDK/components/boards/: boards.c
  group Board Support
    ../nRF5_SDK/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nRF5_SDK/components/ble/ble_advertising/: ble_advertising.c
    ../nRF5_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../nRF5_SDK/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_Drivers
    ../nRF5_SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../nRF5_SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nRF5_SDK/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../nRF5_SDK/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../nRF5_SDK/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../nRF5_SDK/components/drivers_nrf/rtc/: nrf_drv_rtc.c
  group nRF_Libraries
    ../nRF5_SDK/components/libraries/button/: app_button.c
    ../nRF5_SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../nRF5_SDK/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK/components/libraries/timer/: app_timer.c
    ../nRF5_SDK/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../nRF5_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../nRF5_SDK/components/libraries/experimental_memobj/: nrf_memobj.c
    ../nRF5_SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF5_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF5_SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../nRF5_SDK/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../nRF5_SDK/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../nRF5_SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_5.0.0_softdevice (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\Source\inc
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.14.1
